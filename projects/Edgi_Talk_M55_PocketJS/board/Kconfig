## projects/Edgi_Talk_M55_PocketJS/board/Kconfig
```kconfig
menu "PocketJS Configuration"

    config BSP_USING_POCKETJS
        bool "Enable PocketJS runtime"
        default y

endmenu
```
